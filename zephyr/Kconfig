## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: MIT

config NNG
	bool "Enable support for nng"

config NNG_WEBSOCKETS
	bool "Enable Web Sockets in NNG"
	depends on NNG
	default y
```
